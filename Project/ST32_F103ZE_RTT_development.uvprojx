# Keil uVision project ST32_F103ZE_RTT_development.uvprojx, settings and files
target stm32f103zet6rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ST32_F103ZE_RTT_development +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,RT_USING_DEVICE
  c include: ..\Core\Inc;..\Driver;..\Driver\Inc;..\Middle\Inc;..\rtthread\include;..\rtthread\include\libc;..\rtthread\components\finsh;..\rtthread;..\rtthread\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../main/: main.c
    ../rtthread/: board.c rtconfig.h
  group driver
    ../Driver/Src/: buzzer.c key.c rgb.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c uart.c stm32f10x_it.c misc.c
  group core
    ../Core/Src/: system_stm32f10x.c
    ../Core/Inc/: stm32f10x_conf.h stm32f10x.h system_stm32f10x.h
    ../Core/: startup_stm32f10x_hd.s
  group rt-thread\src
    ../rtthread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rt-thread\ports
    ../rtthread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
